# KOMPAS-3D drawing (чертеж2.cdw)

Views: Вид 1
Texts:
  Matroolya
  Стили документа
Dimensions and other numbers on the sheet: 2; 4; 3; 7; 6; 10; 17; 1:1; 1